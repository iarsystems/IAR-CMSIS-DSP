<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\arm_cortexM_math.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>arm_cortexM_math</name>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM0b</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM0l</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM3b</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM3l</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM4b</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM4bf</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM4l</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM7b</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM7l</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM7bf</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM7bs</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM7lf</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>cortexM7ls</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MBLl</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MMLl</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MMLld</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MMLldfdp</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MMLldfsp</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MMLlfdp</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv8MMLlfsp</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv81MLld</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv81MLldfdp</configuration>
            </member>
            <member>
                <project>arm_cortexM_math</project>
                <configuration>ARMv81MLldfdph</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
