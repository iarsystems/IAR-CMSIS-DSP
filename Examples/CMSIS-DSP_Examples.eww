<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\arm_bayes_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_class_marks_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_convolution_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_dotproduct_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_fft_bin_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_fir_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_graphic_equalizer_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_linear_interp_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_matrix_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_signal_converge_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_sin_cos_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_svm_example.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\arm_variance_example.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>CMSIS-DSP_all</name>
            <member>
                <project>arm_bayes_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_class_marks_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_convolution_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_dotproduct_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_fft_bin_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_fir_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_graphic_equalizer_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_linear_interp_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_matrix_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_signal_converge_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_sin_cos_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_svm_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
            <member>
                <project>arm_variance_example</project>
                <configuration>cortexM4lf</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
